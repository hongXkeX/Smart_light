# Keil uVision project winning V0.2.uvproj, settings and files
target V0.3 基本识别 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: winning V0.2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group APP
    ../code/: main.c Reg_RW.c LDChip.c
  group Driver
    ../user/: usart.c
